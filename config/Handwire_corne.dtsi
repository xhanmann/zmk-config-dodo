#include <physical_layouts.dtsi>
#include <dt-bindings/zmk/matrix_transform.h>

/ {
  },
  "ws2812": {
    "pin": "GP16",
    "driver": "vendor"
  },
  "rgblight": {
    "led_count": 1,
    "layers": {
      "enabled": true
    
chosen {
        zmk,physical-layout = &layout;
    };

    kscan: kscan {
        compatible = "zmk,kscan-gpio-matrix";
        diode-direction = "col2row";

        row-gpios=


   };

    transform: matrix_transform {
        compatible = "zmk,matrix-transform";
        rows = <4>;
        columns = <6>;
